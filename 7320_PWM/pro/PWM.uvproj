# Keil uVision project PWM.uvproj, settings and files
target pwm (MCS-51)
  device: SC92F7320 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(24000000)
  output: PWM +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\bsp;..\lib;..\user
  group startup
    ./: STARTUP.A51
  group user
    ../user/: main.c system.c
  group lib
    ../lib/: SC92F732X_C.H
  group bsp
    ../bsp/: bsp_led.c bsp_pwm.C bsp_timer.c TimeOut.c
